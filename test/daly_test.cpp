// DALY decoders against real captured frames (from syssi/esphome-daly-bms test data).
#include "../include/bms_daly.h"
#include <cassert>
#include <cmath>
#include <cstdio>
#include <vector>
static const std::vector<uint8_t> S80 = {
    0xD2, 0x03, 0xA0, 0x0C, 0xCF, 0x0C, 0xD1, 0x0C, 0xD1, 0x0C, 0xD1, 0x0C, 0xD1, 0x0C, 0xD1, 0x0C, 0xD2, 0x0C, 0xD2,
    0x0C, 0xD2, 0x0C, 0xD2, 0x0C, 0xD0, 0x0C, 0xD1, 0x0C, 0xD2, 0x0C, 0xD2, 0x0C, 0xD2, 0x0C, 0xD1, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x37, 0x00, 0x37, 0x00, 0x37, 0x00, 0x37, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x0D, 0x75, 0x11, 0x02, 0x12, 0x0C, 0xD2, 0x0C, 0xCF, 0x00, 0x37,
    0x00, 0x37, 0x00, 0x02, 0x04, 0x59, 0x00, 0x10, 0x00, 0x04, 0x00, 0x39, 0x00, 0x00, 0x00, 0x01, 0x00, 0x01, 0x0C,
    0xD1, 0x00, 0x03, 0x00, 0xA2, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x75, 0x30,
    0x00, 0x00, 0x00, 0x37, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x44, 0x82};
static const std::vector<uint8_t> S62 = {
    0xD2, 0x03, 0x7C, 0x0D, 0x6E, 0x0D, 0x69, 0x0D, 0x59, 0x0D, 0xD7, 0x0D, 0x0B, 0x0D, 0x0B, 0x0D, 0x0C, 0x0D, 0x0B,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3D, 0x00, 0x28, 0x00, 0x28, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x0F, 0x75, 0x30, 0x03, 0xE8, 0x0D, 0xD7, 0x0D, 0x0B, 0x00, 0x3D,
    0x00, 0x3D, 0x00, 0x00, 0x00, 0xFA, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x01, 0x0D,
    0x46, 0x00, 0xCC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0xE1};
static void put16(std::vector<uint8_t> &v, uint16_t x) { v.push_back(x >> 8); v.push_back(x); }
static std::vector<uint8_t> reply(uint8_t start, const std::vector<uint16_t> &regs) {
  std::vector<uint8_t> f = {start, 0x03, uint8_t(regs.size() * 2)};
  for (auto r : regs) put16(f, r);
  uint16_t c = daly::crc16(f.data(), f.size());
  f.push_back(c & 0xFF); f.push_back(c >> 8);
  return f;
}
int main() {
  uint8_t f[16];
  daly::d2Frame(f, 0xD2, 3, 0, 0x3E);
  assert(f[6] == 0xD7 && f[7] == 0xB9);
  // Bluetooth status frames, fed byte by byte with junk in front
  for (auto *fr : {&S80, &S62}) {
    daly::D2Framer F;
    int calls = 0;
    std::vector<uint8_t> in = {0x00, 0xD2, 0x11};
    in.insert(in.end(), fr->begin(), fr->end());
    for (uint8_t c : in) F.feed(&c, 1, [&](uint8_t st, uint8_t fn, const uint8_t *d, size_t n) {
      assert(st == 0xD2 && fn == 3);
      jk::Sample s; uint8_t bal;
      assert(daly::decodeBle(d, n, s, bal));
      calls++;
      if (fr == &S80) {
        printf("D2 80: V=%.1f I=%.1f soc=%.0f n=%u cap=%.1f cyc=%u t1=%.0f chg=%d dsg=%d mos=%.0f\n", s.voltage, s.current, s.soc, s.count, s.capacity, s.cycles, s.temp1, s.charge, s.discharge, s.mos);
        assert(std::fabs(s.voltage - 52.5f) < .01 && std::fabs(s.current + 3.1f) < .01 && std::fabs(s.soc - 53) < .01);
        assert(s.count == 16 && std::fabs(s.capacity - 111.3f) < .01 && s.cycles == 57 && s.temp1 == 15 && s.charge && s.discharge && !bal);
      } else {
        printf("D2 62: V=%.1f I=%.1f soc=%.0f n=%u cap=%.1f c1=%.3f\n", s.voltage, s.current, s.soc, s.count, s.capacity, s.cells[0]);
        assert(std::fabs(s.voltage - 27.1f) < .01 && s.count == 8 && std::fabs(s.soc - 100) < .01 && std::fabs(s.capacity - 25) < .01 && std::fabs(s.cells[0] - 3.438f) < 1e-4);
      }
    });
    assert(calls == 1 && F.good == 1);
  }
  // Wire (address 1 -> reply start 0x51): three blocks
  {
    daly::WireRegs W;
    daly::D2Framer F;
    std::vector<uint16_t> b0(32, 0); for (int i = 0; i < 16; i++) b0[i] = 3300 + i;
    std::vector<uint16_t> b1(0x18, 0); b1[0] = 65; b1[1] = 66; b1[8] = 529; b1[9] = 30000 - 125; b1[10] = 755; b1[12] = 16; b1[13] = 2;
    std::vector<uint16_t> b2(0x15, 0); b2[0x4B - 0x48] = 2104; b2[0x4C - 0x48] = 31; b2[0x52 - 0x48] = 1; b2[0x53 - 0x48] = 1; b2[0x5A - 0x48] = 72;
    int blk = 0;
    for (auto *r : {&b0, &b1, &b2}) {
      auto fr = reply(0x51, *r);
      F.feed(fr.data(), fr.size(), [&](uint8_t st, uint8_t fn, const uint8_t *d, size_t n) { assert(st == 0x51 && fn == 3); W.store(blk, d, n); });
      blk++;
    }
    jk::Sample s;
    assert(daly::decodeWire(W, s));
    printf("wire: V=%.1f I=%.1f soc=%.1f n=%u cap=%.1f cyc=%u t1=%.0f mos=%.0f chg=%d\n", s.voltage, s.current, s.soc, s.count, s.capacity, s.cycles, s.temp1, s.mos, s.charge);
    assert(s.count == 16 && std::fabs(s.current + 12.5f) < .01 && std::fabs(s.soc - 75.5f) < .01 && s.cycles == 31 && s.temp1 == 25 && s.mos == 32 && s.charge && s.discharge);
    // write echo
    daly::d2Frame(f, 0x81, 6, 0x0121, 0);
    int echo = 0;
    uint8_t e[8]; memcpy(e, f, 8); e[0] = 0x51; uint16_t c = daly::crc16(e, 6); e[6] = c & 0xFF; e[7] = c >> 8;
    F.feed(e, 8, [&](uint8_t, uint8_t fn, const uint8_t *, size_t) { echo += fn == 6; });
    assert(echo == 1);
  }
  // Older DALY: A5 frames
  {
    daly::A5Framer F;
    daly::A5State st;
    bool done = false;
    auto ans = [&](uint8_t id, std::vector<uint8_t> d) {
      uint8_t fr[13] = {0xA5, 0x01, id, 0x08};
      for (int i = 0; i < 8; i++) fr[4 + i] = i < (int)d.size() ? d[i] : 0;
      uint8_t s = 0; for (int i = 0; i < 12; i++) s += fr[i]; fr[12] = s;
      F.feed(fr, 13, [&](uint8_t i, const uint8_t *dd) { if (st.add(i, dd)) done = true; });
    };
    ans(0x90, {0x02, 0x10, 0, 0, 0x75, 0x8E, 0x02, 0xEE}); // 52.8 V, +9.4 A, 75.0 %
    ans(0x93, {1, 1, 1, 0, 0x00, 0x03, 0x34, 0x50});        // 210 Ah
    ans(0x94, {16, 2, 0, 0, 0, 0x00, 0x2A});                // 16 cells, 42 cycles
    for (int fr = 1; fr <= 6; fr++) ans(0x95, {uint8_t(fr), 0x0C, 0xE4, 0x0C, 0xE4, 0x0C, 0xE4});
    ans(0x96, {1, 65, 66});
    assert(done);
    printf("A5: V=%.1f I=%.1f soc=%.0f n=%u cap=%.0f cyc=%u t1=%.0f\n", st.s.voltage, st.s.current, st.s.soc, st.s.count, st.s.capacity, st.s.cycles, st.s.temp1);
    assert(st.s.count == 16 && std::fabs(st.s.current - 9.4f) < .01 && st.s.cycles == 42 && std::fabs(st.s.capacity - 210) < .01 && st.s.temp1 == 25);
    uint8_t q[13]; daly::a5Frame(q, 0x40, 0x90);
    assert(q[12] == uint8_t(0xA5 + 0x40 + 0x90 + 0x08));
  }
  puts("PASS daly_test");
}
